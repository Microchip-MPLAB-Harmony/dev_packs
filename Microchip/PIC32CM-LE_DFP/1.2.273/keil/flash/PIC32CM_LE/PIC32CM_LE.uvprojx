# Keil uVision project PIC32CM_LE.uvprojx, settings and files
target PIC32CM1216-LE_FLASH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.1-dev0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: PIC32CM1216LE_FLASH
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=2
  c define: FLASH_MEM PIC32CM1216LE
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target PIC32CM2532-LE_FLASH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.1-dev0
  cpu: as above
  output: PIC32CM2532LE_FLASH
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=2
  c define: FLASH_MEM PIC32CM2532LE
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PIC32CM5164-LE_FLASH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.1-dev0
  cpu: as above
  output: PIC32CM5164LE_FLASH
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=2
  c define: FLASH_MEM PIC32CM5164LE
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PIC32CM2532-LE_DFLASH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.1-dev0
  cpu: as above
  output: PIC32CM2532LE_DFLASH
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=2
  c define: DATA_FLASH PIC32CM2532LE
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PIC32CM5164-LE_DFLASH (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.1-dev0
  cpu: as above
  output: PIC32CM5164LE_DFLASH
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=2
  c define: DATA_FLASH PIC32CM5164LE
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target PIC32CM-LE_UROW (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.1-dev0
  cpu: as above
  output: PIC32CMLE_UROW
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=2
  c define: FLASH_UROW PIC32CM5164LE
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
