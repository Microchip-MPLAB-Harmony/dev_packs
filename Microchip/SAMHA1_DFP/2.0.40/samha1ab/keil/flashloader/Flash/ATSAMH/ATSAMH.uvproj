# Keil uVision project ATSAMH.uvproj, settings and files
target ATSAMH_16 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMH_16
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMH_16 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target ATSAMH_32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMH_32
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMH_32 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAMH_64 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMH_64
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMH_64 FLASH_MEM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAMH_16_EEPROM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMH_16_EEPROM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMH_16 FLASH_EEPROM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAMH_32_EEPROM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMH_32_EEPROM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMH_32 FLASH_EEPROM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target ATSAMH_64_EEPROM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ATSAMH_64_EEPROM
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3
  c define: ATSAMH_64 FLASH_EEPROM
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
