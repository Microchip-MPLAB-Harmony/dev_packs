# Keil uVision project Blinky.uvprojx, settings and files
target SAML10 Flash (6100000::V6.10::.\ARMCLANG)
  device: ATSAML10E16A Microchip
  pack: Keil.SAML10_DFP.1.0.133
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x10000) IROM2(0x00400000,0x800) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x400000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source Group 1
    ./: main.c
  group Dokumentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
